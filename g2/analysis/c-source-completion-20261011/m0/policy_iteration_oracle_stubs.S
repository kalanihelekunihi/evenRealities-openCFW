.syntax unified
.thumb
.text
.global case_ack
.thumb_func
case_ack:
bx lr
.global case_binary_3f_enable
.thumb_func
case_binary_3f_enable:
bx lr
.global case_boot_bus_set_frequency
.thumb_func
case_boot_bus_set_frequency:
bx lr
.global case_boot_irq_disable
.thumb_func
case_boot_irq_disable:
bx lr
.global case_boot_option_commit_a
.thumb_func
case_boot_option_commit_a:
bx lr
.global case_boot_option_commit_b
.thumb_func
case_boot_option_commit_b:
bx lr
.global case_boot_option_commit_c
.thumb_func
case_boot_option_commit_c:
bx lr
.global case_boot_option_erase_execute
.thumb_func
case_boot_option_erase_execute:
bx lr
.global case_boot_option_prepare
.thumb_func
case_boot_option_prepare:
bx lr
.global case_boot_option_unlock
.thumb_func
case_boot_option_unlock:
bx lr
.global case_boot_option_write
.thumb_func
case_boot_option_write:
bx lr
.global case_boot_pin_config
.thumb_func
case_boot_pin_config:
bx lr
.global case_boot_pool_wake_waiter
.thumb_func
case_boot_pool_wake_waiter:
bx lr
.global case_boot_read_option_words
.thumb_func
case_boot_read_option_words:
bx lr
.global case_boot_sensor_finish_guard
.thumb_func
case_boot_sensor_finish_guard:
bx lr
.global case_boot_sensor_flags_5f44
.thumb_func
case_boot_sensor_flags_5f44:
bx lr
.global case_boot_sensor_post_transmit
.thumb_func
case_boot_sensor_post_transmit:
bx lr
.global case_boot_sensor_send_packet
.thumb_func
case_boot_sensor_send_packet:
bx lr
.global case_boot_sensor_service_start
.thumb_func
case_boot_sensor_service_start:
bx lr
.global case_boot_transport_registration_storage
.thumb_func
case_boot_transport_registration_storage:
bx lr
.global case_bus_finish
.thumb_func
case_bus_finish:
bx lr
.global case_bus_gpio_config
.thumb_func
case_bus_gpio_config:
bx lr
.global case_bus_poll
.thumb_func
case_bus_poll:
bx lr
.global case_bus_prepare
.thumb_func
case_bus_prepare:
bx lr
.global case_bus_read
.thumb_func
case_bus_read:
bx lr
.global case_bus_send
.thumb_func
case_bus_send:
bx lr
.global case_bus_start
.thumb_func
case_bus_start:
bx lr
.global case_control_write
.thumb_func
case_control_write:
bx lr
.global case_init_boost_set
.thumb_func
case_init_boost_set:
bx lr
.global case_init_pmic_read
.thumb_func
case_init_pmic_read:
bx lr
.global case_init_power_set
.thumb_func
case_init_power_set:
bx lr
.global case_init_wake_clock
.thumb_func
case_init_wake_clock:
bx lr
.global case_init_wake_config
.thumb_func
case_init_wake_config:
bx lr
.global case_init_wake_mask
.thumb_func
case_init_wake_mask:
bx lr
.global case_legacy_logger
.thumb_func
case_legacy_logger:
bx lr
.global case_policy_system_reset
.thumb_func
case_policy_system_reset:
bx lr
.global case_policy_timer_device_read
.thumb_func
case_policy_timer_device_read:
bx lr
.global case_record_dispatch_1e94
.thumb_func
case_record_dispatch_1e94:
bx lr
.global log_hex_buffer
.thumb_func
log_hex_buffer:
bx lr
.section .rodata
 .global case_crt_initial_data
case_crt_initial_data:
.space 104
 .global case_policy_ota_probe_template
case_policy_ota_probe_template:
.space 12
